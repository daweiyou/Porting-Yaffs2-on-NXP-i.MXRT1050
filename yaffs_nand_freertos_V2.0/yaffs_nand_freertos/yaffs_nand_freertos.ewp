# IAR project yaffs_nand_freertos.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1052DVL6B; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SD_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; source; CMSIS; component/lists; component/osa; component/serial_manager; component/uart; device; drivers; fatfs/source; fatfs/source/fsl_sd_disk; freertos/freertos_kernel/include; freertos/freertos_kernel/portable/IAR/ARM_CM4F; sdmmc/host; sdmmc/inc; sdmmc/osa; startup; utilities; xip
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: yaffs_nand_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1052DVL6B; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SD_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1052DVL6B; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SD_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1052DVL6B; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SD_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1052DVL6B; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SD_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1052DVL6B; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SD_ENABLED; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
configuration flexspi_nor_sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; CPU_MIMXRT1052DVL6B; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_RTOS_FREE_RTOS; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; ENABLE_YAFFS_TRACE=0; SERIAL_PORT_TYPE_UART=1; ENABLE_RTS_TRANSCEIVER=0; SWO_PRINTF=0
  ICCARM.CCIncludePath2: board; source; CMSIS; component/lists; component/osa; component/serial_manager; component/uart; device; drivers; fatfs/source; fatfs/source/fsl_sd_disk; freertos/freertos_kernel/include; freertos/FreeRTOS-Plus-CLI; freertos/freertos_kernel/portable/IAR/ARM_CM4F; sdmmc/host; sdmmc/inc; sdmmc/osa; startup; utilities; xip; source/bsp/nand; source/bsp/led; source/bsp/private_uart; source/yaffs2; source/yaffs2/port; source/cli
  OBJCOPY.OOCOutputFile: yaffs_nand_freertos.srec
  ILINK.IlinkConfigDefines: __stack_size__=0x4000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor_sdram.icf
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    component/lists/: generic_list.c generic_list.h
  group component/osa
    component/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group component/serial_manager
    component/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/uart
    component/uart/: lpuart_adapter.c uart.h
  group device
    device/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_semc.c fsl_semc.h fsl_semc_old.c fsl_semc_old.h fsl_usdhc.c fsl_usdhc.h
  group evkbimxrt1050
    evkbimxrt1050/: evkbimxrt1050.mac
  group fatfs/source
    fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group freertos/FreeRTOS-Plus-CLI
    freertos/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c FreeRTOS_CLI.h
  group freertos/freertos_kernel
    freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/freertos_kernel/portable
    freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    freertos/freertos_kernel/portable/MemMang/: heap_4.c
  group MIMXRT1052/iar
    MIMXRT1052/iar/: MIMXRT1052xxxxx_ram.icf
  group sdmmc
    sdmmc/: ChangeLogKSDK.txt
  group sdmmc/host
    sdmmc/host/: ChangeLogKSDK.txt fsl_sdmmc_host.c fsl_sdmmc_host.h
  group sdmmc/inc
    sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group sdmmc/osa
    sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
  group sdmmc/src
    sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group source
    source/: ffconf.h FreeRTOSConfig.h yaffs_freertos.c
  group source/bsp/led
    source/bsp/led/: bsp_led.c bsp_led.h
  group source/bsp/nand
    source/bsp/nand/: bsp_nand.c bsp_nand.h fsl_nand_flash.h fsl_semc_nand_flash.c fsl_semc_nand_flash.h nand_flash_test.c
  group source/bsp/private_uart
    source/bsp/private_uart/: lpuart_freertos_cfg.h private_lpuart_freertos.c private_lpuart_freertos.h
  group source/cli
    source/cli/: Basic-CLI-commands.c File-Related-CLI-commands.c systimer.c UARTCommandConsole.c
  group source/yaffs
    source/yaffs2/: nand_chip.h nand_store.h nanddrv.h yaffs_allocator.c yaffs_allocator.h yaffs_attribs.c yaffs_attribs.h yaffs_bitmap.c yaffs_bitmap.h yaffs_checkptrw.c yaffs_checkptrw.h yaffs_ecc.c yaffs_ecc.h yaffs_endian.c yaffs_endian.h yaffs_error.c yaffs_flashif.h yaffs_flashif2.h yaffs_getblockinfo.h yaffs_guts.c yaffs_guts.h yaffs_hweight.c yaffs_hweight.h yaffs_list.h yaffs_nameval.c yaffs_nameval.h yaffs_nand.c yaffs_nand.h yaffs_nand_drv.h yaffs_nandemul2k.h yaffs_osglue.h yaffs_packedtags1.c yaffs_packedtags1.h yaffs_packedtags2.c yaffs_packedtags2.h yaffs_summary.c yaffs_summary.h yaffs_tagscompat.c yaffs_tagscompat.h yaffs_tagsmarshall.c yaffs_tagsmarshall.h yaffs_trace.h yaffs_verify.c yaffs_verify.h yaffs_yaffs1.c yaffs_yaffs1.h yaffs_yaffs2.c yaffs_yaffs2.h yaffscfg.h yaffsfs.c yaffsfs.h ydirectenv.h
  group source/yaffs/port
    source/yaffs2/port/test_framework/: dtest.c yaffs_test.c
    source/yaffs2/port/: yaffs_nand_drv.c yaffs_osglue_freertos.c yaffscfg2k.c yportenv.h
  group startup
    startup/: startup_MIMXRT1052.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_shell.c fsl_shell.h fsl_str.c fsl_str.h
  group xip
    xip/: fire_imxrt1052_sdram_ini_dcd.c fire_imxrt1052_sdram_ini_dcd.h fire_imxrt1052_spiflash_config.c fire_imxrt1052_spiflash_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
